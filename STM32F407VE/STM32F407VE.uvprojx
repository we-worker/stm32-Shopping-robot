# Keil uVision project STM32F407VE.uvprojx, settings and files
target STM32F407VE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VE
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,EMPL_TARGET_STM32,MPU6050
  c include: .\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\User;.\eMPL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c delay.c KeyLed.c BTModule.c stdout_user.c MotorDriver.c MotorController.c amt1450_uart.c tcrt5000.c tcrt5000.h PID.c PID.h DFS_Map.c DFS_Map.h NanoCommunication.c NanoCommunication.h ArmSolution.c ArmSolution.h
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c misc.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_dcmi.c
software components: Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0
